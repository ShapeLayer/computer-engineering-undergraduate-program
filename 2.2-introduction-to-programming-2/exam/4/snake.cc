#include <iostream>
using namespace std;

/**
 * problem.md 2025-12-06
1 / 3
問題1 スネーク状の⾏列出⼒
⾏列の⾏数 N と列数 M が与えられ，続けて N × M 個の整数が与えられる．
행렬 N의 행 수와 열 M의 수를 주고, 그 다음에 정수 N× M의 수를 제시한다.
この⾏列の要素を，次のルールにしたがって「スネーク状」に並べて出⼒せよ．
다음 규칙에 따라 이 행렬의 원소들을 뱀(snake) 모양으로 출력
0 ⾏⽬，2 ⾏⽬，4 ⾏⽬，…（偶数⾏）は，左から右へ出⼒する．
0호선, 2호선, 4호선,... (짝수 선)은 왼쪽에서 오른쪽으로 출력
1 ⾏⽬，3 ⾏⽬，5 ⾏⽬，…（奇数⾏）は，右から左へ出⼒する．
1호선, 3호선, 5호선,... (홀수 선)은 오른쪽에서 왼쪽으로 출력
すべての要素をこの順に 1 ⾏で出⼒し，各要素の間は 1 個の半⾓スペースで区切ること．
모든 요소는 한 줄로 이 순서로 출력되어야 하며, 각 요소는 반각공백으로 분리
⾏末にも改⾏⽂字を 1 つ出⼒してよい．
행말 개행 앞에 개해움ㄴ자 한개 넣어도 된다.
⼊⼒
⼊⼒は次の形式で標準⼊⼒から与えられる．

N M
a11 a12 ... a1M
a21 a22 ... a2M
...
aN1 aN2 ... aNM
1 ⾏⽬に⾏数 N と列数 M が与えられる．
続く N ⾏それぞれに，M 個の整数 a_ij が与えられる．
制約
1 ≤ N ≤ 50
1 ≤ M ≤ 50
a_ij は整数であり，32 ビット符号付き整数型に収まる範囲とする．
⼊⼒は上記形式にしたがって与えられる（異常な⼊⼒は与えられない）．
出⼒
⾏列の要素をスネーク状に並べた列を，1 ⾏で出⼒せよ．
出⼒する要素の個数は常に N × M 個である．
要素と要素の間は 1 個の半⾓スペースで区切ること．
⾏末には改⾏⽂字を 1 つ出⼒してよい．
サンプル
サンプル 1
problem.md 2025-12-06
2 / 3
⼊⼒
3 4
1 2 3 4
5 6 7 8
9 10 11 12
出⼒
1 2 3 4 8 7 6 5 9 10 11 12
サンプル 2
⼊⼒
3 6
10 20 30 40 50 60
99 88 77 66 55 44
1 2 3 4 5 6
出⼒
10 20 30 40 50 60 44 55 66 77 88 99 1 2 3 4 5 6
サンプル 3
⼊⼒
6 3
1 2 3
4 5 6
7 8 9
10 11 12
13 14 15
16 17 18
出⼒
1 2 3 6 5 4 7 8 9 12 11 10 13 14 15 18 17 16
problem.md 2025-12-06
3 / 3
実装上の注意
⼊⼒は必ず上記の制約を満たすと仮定してよいので，⾏列サイズのチェックやエラーメッセージの出⼒は不要である．
出⼒の前後や⾏末の余分な空⽩⽂字は採点に影響する場合がある．
要素間だけにスペースが⼊るように実装することを推奨する．
구현 노트
입력이 항상 위의 제약 조건을 만족하므로 행렬 크기를 확인하고 오류 메시지를 출력은 불필요
출력 전후나 줄 끝에 여백이 있으면 점수에 영향을 줄 수 있음
요소 사이에 공백 들어갈 수 있도록 구현하는 것이 권장

 */

int main() {
    int N, M;
    cin >> N >> M;

    int matrix[50][50];

    // 行列の読み込み
    for (int i = 0; i < N; i++) {
        for (int j = 0; j < M; j++) {
            cin >> matrix[i][j];
        }
    }

    // スネーク状に出力
    for (int i = 0; i < N; i++) {
        // ★★ 回答者が修正する行（i が奇数行のとき true になるようにする）★★
        bool reverse = i % 2;  // TODO: i の偶奇に応じて書き換える

        if (!reverse) {
            // 左から右へ
            for (int j = 0; j < M; j++) {
                cout << matrix[i][j];
                if (!(i == N - 1 && j == M - 1)) {
                    cout << ' ';
                }
            }
        } else {
            // 右から左へ
            for (int j = M - 1; j >= 0; j--) {
                cout << matrix[i][j];
                if (!(i == N - 1 && j == 0)) {
                    cout << ' ';
                }
            }
        }
    }

    cout << '\n';
    return 0;
}
