#include <iostream>
#include <string>
using namespace std;

/**
 * problem.md 2025-12-06
1 / 3
問題2 ⾁じゃがの作り⽅
⾁じゃがは，炒める具材の順番で味が変わると⾔われている．
니쿠자가 맛은 튀기는 재료의 순서에 따라 달라진다
次の 7 つの具材を，最初は次の順番で並べておく．
7개 재료 순서대로 배열
⽟ねぎ 양파
⾁ 고기
じゃがいも 감자
にんじん 당근
砂糖 설탕
醤油 간장
みりん 미림
このうち 2 つの具材名が⼊⼒として与えられる．
두 가지 재료명이 입력
与えられた 2 つの具材の位置を⼊れ替えたときの具材の並びを，先頭から順に 1 ⾏ずつ出⼒せよ．
두 재료가 바뀔 때 재료 순서를 한 줄씩, 처음부터 출력
なお，2 つの具材名は上記 7 種類のいずれかであり，同じ具材名が 2 回⼊⼒される場合もある．
두 가지 재료명은 위의 일곱 가지 유형 중 하나이며, 같은 재료명을 두 번 입력할 수 있음
2 つの具材名が同じ場合は，具材の順番は変化しないものとする．
두 재료가 같은 이름을 가진 경우, 재료 순서는 변하지 않음
⼊⼒
⼊⼒は次の形式で標準⼊⼒から与えられる．
s1 s2
s1 と s2 は，次のいずれかの⽂字列である．
⽟ねぎ
⾁
じゃがいも
にんじん
砂糖
醤油
みりん
s1 と s2 は半⾓スペース区切りで 1 ⾏に与えられる．
s1 と s2 が同じ⽂字列である場合もある．
制約
s1 と s2 は上記 7 種類のいずれかである．
⼊⼒は問題⽂に記載された形式にしたがって与えられる（異常な⼊⼒は与えられない）．
出⼒
problem.md 2025-12-06
2 / 3
もとの具材の順番
1. ⽟ねぎ
2. ⾁
3. じゃがいも
4. にんじん
5. 砂糖
6. 醤油
7. みりん
のうち，⼊⼒された 2 つの具材の位置を⼊れ替えたあとの順番を，先頭から順に 1 ⾏ずつ出⼒せよ．
出⼒は必ず 7 ⾏となる．
各⾏には具材名のみを出⼒し，余分な空⽩は出⼒しないこと．
⾏末には改⾏⽂字を 1 つ出⼒してよい．
サンプル
サンプル 1
⼊⼒
⽟ねぎ じゃがいも
出⼒
じゃがいも
⾁
⽟ねぎ
にんじん
砂糖
醤油
みりん
サンプル 2
⼊⼒
⾁ 醤油
出⼒
problem.md 2025-12-06
3 / 3
⽟ねぎ
醤油
じゃがいも
にんじん
砂糖
⾁
みりん
サンプル 3
⼊⼒
にんじん にんじん
出⼒
⽟ねぎ
⾁
じゃがいも
にんじん
砂糖
醤油
みりん
（同じ具材を 2 回指定した場合は，順番は変化しない．）
実装上の注意
⼊⼒として与えられる具材名は，問題⽂に挙げた 7 種類のいずれかであると仮定してよい．
2 つの具材名が異なる場合は，その 2 つの位置を⼊れ替えればよい．
2 つの具材名が同じ場合は，具材の順番を変更しないこと．
出⼒は 7 ⾏の具材名のみとし，余計なメッセージや空⽩を出⼒しないこと．
problem.md 2025-12-06
1 / 3
問題2 ⾁じゃがの作り⽅
⾁じゃがは，炒める具材の順番で味が変わると⾔われている．
次の 7 つの具材を，最初は次の順番で並べておく．
⽟ねぎ
⾁
じゃがいも
にんじん
砂糖
醤油
みりん
このうち 2 つの具材名が⼊⼒として与えられる．
与えられた 2 つの具材の位置を⼊れ替えたときの具材の並びを，先頭から順に 1 ⾏ずつ出⼒せよ．
なお，2 つの具材名は上記 7 種類のいずれかであり，同じ具材名が 2 回⼊⼒される場合もある．
2 つの具材名が同じ場合は，具材の順番は変化しないものとする．
⼊⼒
⼊⼒は次の形式で標準⼊⼒から与えられる．
s1 s2
s1 と s2 は，次のいずれかの⽂字列である．
⽟ねぎ
⾁
じゃがいも
にんじん
砂糖
醤油
みりん
s1 と s2 は半⾓スペース区切りで 1 ⾏に与えられる．
s1 と s2 が同じ⽂字列である場合もある．
制約
s1 と s2 は上記 7 種類のいずれかである．
⼊⼒は問題⽂に記載された形式にしたがって与えられる（異常な⼊⼒は与えられない）．
出⼒
problem.md 2025-12-06
2 / 3
もとの具材の順番
1. ⽟ねぎ
2. ⾁
3. じゃがいも
4. にんじん
5. 砂糖
6. 醤油
7. みりん
のうち，⼊⼒された 2 つの具材の位置を⼊れ替えたあとの順番を，先頭から順に 1 ⾏ずつ出⼒せよ．
出⼒は必ず 7 ⾏となる．
各⾏には具材名のみを出⼒し，余分な空⽩は出⼒しないこと．
⾏末には改⾏⽂字を 1 つ出⼒してよい．
サンプル
サンプル 1
⼊⼒
⽟ねぎ じゃがいも
出⼒
じゃがいも
⾁
⽟ねぎ
にんじん
砂糖
醤油
みりん
サンプル 2
⼊⼒
⾁ 醤油
出⼒
problem.md 2025-12-06
3 / 3
⽟ねぎ
醤油
じゃがいも
にんじん
砂糖
⾁
みりん
サンプル 3
⼊⼒
にんじん にんじん
出⼒
⽟ねぎ
⾁
じゃがいも
にんじん
砂糖
醤油
みりん
（同じ具材を 2 回指定した場合は，順番は変化しない．）
実装上の注意
⼊⼒として与えられる具材名は，問題⽂に挙げた 7 種類のいずれかであると仮定してよい．
2 つの具材名が異なる場合は，その 2 つの位置を⼊れ替えればよい．
2 つの具材名が同じ場合は，具材の順番を変更しないこと．
出⼒は 7 ⾏の具材名のみとし，余計なメッセージや空⽩を出⼒しないこと．
구현 노트
입력으로 주어진 재료명은 문제 문장에 나열된 일곱 가지 유형 중 하나라고 가정할 수 있음
두 재료 이름이 다르면 두 위치를 바꿔 쓸 수 있음
두 재료가 같은 이름이라면 재료 순서를 바꾸지 말것
출력은 재료 이름이 7줄만 되어야 하며, 불필요한 메시지나 공백은 인쇄하지 않아야 함

 */
class Node {
public:
    string value;
    Node* next;
};

void printList(Node* head) {
    Node* current = head;
    while (current != NULL) {
        cout << current->value << endl;
        current = current->next;
    }
}

int main() {
    Node* head = NULL;
    Node* tail = NULL;

    Node* a = new Node{ "玉ねぎ", NULL };
    Node* b = new Node{ "肉", NULL };
    Node* c = new Node{ "じゃがいも", NULL };
    Node* d = new Node{ "にんじん", NULL };
    Node* e = new Node{ "砂糖", NULL };
    Node* f = new Node{ "醤油", NULL };
    Node* g = new Node{ "みりん", NULL };

    head = a;
    a->next = b;
    b->next = c;
    c->next = d;
    d->next = e;
    e->next = f;
    f->next = g;
    tail = g;

    string s1, s2;
    cin >> s1 >> s2;

/************** これより上は変更禁止 **************/

    /* ここに回答を記入 */
    // s1 と s2 に対応するノードを探し，異なるノードであれば
    // その value を入れ替える（リスト構造自体は変えない）

    // s1과 s2에 해당하는 노드를 찾고, 만약 이들이 다르다면,
    // 그 값을 바꾸세요 (리스트 구조 자체는 변하지 않습니다)

    Node* n1 = NULL;
    Node* n2 = NULL;

    Node* cur = head;
    if (s1 != s2) {
        while (cur != NULL) {
            if (cur->value == s1) n1 = cur;
            if (cur->value == s2) n2 = cur;
            cur = cur->next;
        }
    }
    
    // 両方見つかり，かつ異なるノードなら，値を入れ替える
    if (n1 != NULL && n2 != NULL && n1 != n2) {
        string tmp = n1->value;
        n1->value = n2->value;
        n2->value = tmp;
    }

/************** これより下は変更禁止 **************/
    printList(head);
}
