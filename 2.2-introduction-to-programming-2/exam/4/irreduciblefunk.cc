#include <iostream>
using namespace std;

/**
 * problem.md 2025-12-06
1 / 3
問題3 既約分数
2 つの分数
( a / b )
( c / d )
（ここで ( a, b, c, d ) はいずれも 1 以上の⾃然数）
a b c d 는 모두 자연수
が与えられる．
가 주어진다
これらの分数を加算し，その結果をユークリッドの互除法を⽤いて 既約分数 に変換して出⼒するプログラムの⼀部，
분수들을 더하고 유클리드 나눗셈 방법을 이용해 결과를 환원 불가능 분수로 변환
関数 gcd と関数 calc を作成せよ．
함수 gcd와 함수 계산을 만들어라
関数 gcd は 2 つの整数の最⼤公約数を返す関数とする．
함수 gcd를 두 정수의 최대공약수 구하는 것
関数 calc は分数 ( a/b ) と ( c/d ) を加算し，既約分数 ( p/q ) を求める関数とする．
함수 계산은 분수 a/b c/d를 가산해 나누는 p/q를 찾는것
... 이거 인기투표 그 문제인데..?
回答部分（gcd および calc の実装部分）において，for ループおよび while ループの使⽤を禁⽌する．
gcd와 calc는 반복문 금지 재귀호출하여라
再帰呼び出しなどを⽤いて実装してよい．
재귀호출을 구현해라?
既約分数とは，分⼦と分⺟の最⼤公約数が 1 である分数のことである．
환원불가능 분수는 최대 공약수와 분모가 1인 분수를 가진 분수
計算結果が整数になる場合（分⺟が 1 になる場合）は，分数ではなく 1 つの⾃然数として出⼒すること．
계산 결과가 종수(분모가 1)이라면 분수가 아닌 자연수로 출력하여라

⼊⼒
⼊⼒は次の形式で標準⼊⼒から与えられる．
a b c d
a, b, c, d は 1 以上の⾃然数である．
4 つの値は半⾓スペース区切りで 1 ⾏に与えられる．
制約
( 1 \leq a, b, c, d \leq 10^9 )
中間計算および最終的な分⼦・分⺟は 64 ビット符号付き整数型 (long long) に収まる範囲であると仮定してよい．
중간 계산과 최종 분자 분자는 ll범위내에있다.
⼊⼒は上記形式および制約を満たすもののみが与えられる（異常な⼊⼒は与えられない）．
입력은 형식에 맞는것만 주어짐

出⼒
分数 ( a/b ) と ( c/d ) を加算した結果を既約分数 ( p/q ) にしたものを出⼒せよ．
분수 a/b와 c/d를 합산한 결과를 환원 불가능 분수로 출력

結果の分⺟ ( q \neq 1 ) のときは

problem.md 2025-12-06
2 / 3
p/q
の形式で出⼒する．（p，/，q のあいだに余分な空⽩は⼊れないこと．）
結果の分⺟ ( q = 1 ) のときは
p
のように，分数ではなく 1 つの⾃然数だけを出⼒する．
出⼒の最後には改⾏⽂字を 1 つ付けてよい．
⼊出⼒例
例 1
⼊⼒
50 100 75 100
出⼒
5/4
（説明）
(50/100 = 1/2)，(75/100 = 3/4) なので，
(1/2 + 3/4 = 5/4) となる．既約分数なのでそのまま 5/4 を出⼒する．
例 2
⼊⼒
5 6 7 6
出⼒
2
problem.md 2025-12-06
3 / 3
（説明）
(5/6 + 7/6 = 12/6 = 2) となるため，分⺟が 1 となり，整数 2 のみを出⼒する．
例 3
⼊⼒
8 9 10 27
出⼒
34/27
（説明）
(8/9 = 24/27)，(10/27) なので，
(24/27 + 10/27 = 34/27) となる．
(34) と (27) の最⼤公約数は 1 であり，既約分数なので 34/27 を出⼒する．
実装上の注意
回答者は，関数 gcd と calc の実装部分のみを編集することを想定している．
gcd および calc の実装では，for ループと while ループの使⽤は禁⽌とする．
再帰呼び出し（再帰関数）を⽤いることで，ユークリッドの互除法を実装できる．
既約分数への変換では，分⼦と分⺟をその最⼤公約数で割ること．
出⼒形式（p/q か p か）や空⽩の扱いに注意すること．

구현 노트
응답자들은 함수 gcd와 calc의 구현만 편집한다고 가정합니
gcd와 calc 구현에서는 for와 while 루프의 사용이 금지
재귀 호출(재귀 함수)을 사용함으로써 유클리드의 나눗셈 방법을 구현 가능
나누어 분할로 변환할 때는 분자와 분자를 최대 공약수로 나누어 나누어 사용
출력 형식(p/q 또는 p)과 여백 처리 방식을 주의

 */
// 2 つの整数 a, b の最大公約数を返す関数
long long gcd(long long a, long long b);

// 分数 a/b, c/d を加算し，既約分数 p/q を求める関数
void calc(long long a, long long b, long long c, long long d,
          long long &p, long long &q);

int main() {
    long long a, b, c, d;
    cin >> a >> b >> c >> d;

    long long p, q;
    calc(a, b, c, d, p, q);

    if (q == 1) {
        cout << p << '\n';
    } else {
        cout << p << '/' << q << '\n';
    }

    return 0;
}

/********************** 回答ここから **********************/

long long gcd(long long a, long long b) {
    // TODO: ユークリッドの互除法を「再帰」で実装する（for, while は使用しない）
    // 仮実装（誤り）：a をそのまま返しているだけ

    // 할 일: 유클리드 재귀 구현
    // 임시 구현(틀림): 그냥 있는 그대로 a를 반환하는 것

    if (a < b) {
        long long tmp = a;
        a = b;
        b = tmp;
    }
    if (b == 0) return a;
    return gcd(a % b, b);
}

void calc(long long a, long long b, long long c, long long d,
          long long &p, long long &q) {
    // TODO: a/b + c/d を計算し，既約分数 p/q にする。
    //       gcd 関数を用いて分子と分母を約分すること。
    long long num = a * d + c * b;
    long long den = b * d;

    // 仮実装（誤り）：約分をせずにそのまま代入
    p = num;
    q = den;

    long long _gcd = gcd(p, q);
    if (_gcd == 0) return;
    p /= _gcd;
    q /= _gcd;
}

/********************** 回答ここまで **********************/
