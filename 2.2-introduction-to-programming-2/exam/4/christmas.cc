#include <iostream>
#include <cstdlib>
using namespace std;

#define RAND_SIZE 256

/**
 * problem.md 2025-12-11
1 / 7
問8（クリスマスツリーのオーナメント管理）
あなたは，クリスマスツリーに配置されたオーナメントのメンテナンスを⾏うプログラムを作成しなければ
ならない．
크리스마스 트리에 놓인 장식 관리 프로그램
ツリーは 完全⼆分⽊ として表現され，各ノードに整数の値 value が格納されている．
트리는 완전 이진 트리 각 노드는 정수 값 저장
value は，そのオーナメントが「設置から何年経過したか」を表す．
value는 오나멘토? 가 설치된지 몇년이 지났는지 표시한다.
value = 9 は「撤去済み（空き）」を表す．
vlaue = 9는 제거됨 (빔) 을 표시
value = 0 〜 5 は通常のオーナメントである．
value 0~5는일반 장식
ツリーの初期状態は，プログラム内で与えられた乱数テーブルから⾃動的に決まるものとする（この部分は
트리의 초기 상태는 프로그램에 제공된 난수 테이블에 의해 자동으로 결정
受験者が変更してはならない）．
メンテナンスは 5 年間 ⾏う．
멘테넌스는5년간 진행
年ごとの処理
연도별처리
メンテナンスは 1 年⽬から 5 年⽬まで，次の処理をこの順番で⾏う︓
메테넌스는 1년차부터 5년차까지 순서대로 처리를 수행
1. 経過年数の加算（2 年⽬以降）
1. 연령수 추가 2년째 이상
2 年⽬〜5 年⽬では，撤去済みでないオーナメントの value を 1 増やす．
具体的には，
2년째부터 5년째까지는 제거되지 않은 장식의 값을 1 올린다.
value が 0〜5 のノードは value = value + 1 とする．
0~5의 노드의 값은 vlaue + 1이다.
value が 9（撤去済み）のノードは変化しない．
9의 경우에는 변화 없음

1 年⽬はこの加算処理を⾏わない（初年度のメンテナンス前の年数はそのまま扱う）．
1년째에는 추가처리는 하지 않음 (첫 해 유지관리 전 년 수는 그대로)

2. 今年追加するオーナメント数の⼊⼒
2. 금년 추가할 오나멘트 수 입력
⼊⼒から今年追加したいオーナメントの個数 K を読み込む．
입력으로 주어진 금년추가할 오너멘트 K가 입력
各年で与えられる K は 0 以上の整数とする．
K는 0이상
3. メンテナンスによる撤去
메인터넨스를 위한 ??
オーナメントの年数が⼀定以上になったものを撤去する．
일정 년식 이상 장식품은 모두 제거
value > 5 のノードを すべて value = 9（空き）に更新する．

それ以外のノードの value はこのステップでは変化しない．
그외의 노드의 값에는 이 단계에서 변화하지 않음
4. オーナメントの追加
4. 오나멘트 추가
その年に追加するオーナメント数 K 個について，次のルールで空きノード（value = 9）へ配置し，
그 년도에 추가할 오너멘트수 K에 대해서 다음의 규칙에 따라서 배치
value = 0 をセットする︓
값이 0을 세트
1. 根に近いノード（上のレベル）から優先して埋める（レベル順）．
1. 근원노드(루트?; 상위레벨)에서부터 채우는 것을 우선순위로 지정 (레벨순)
2. 同じレベルでは 「右の⼦を優先」 して埋める．
2. 같은 수준에서 우측 자식을 우선
すなわち，レベル順探索をするときに，「右の⼦ → 左の⼦」の順で⾛査する．
즉 레벨 순서대로 검색 시 우->좌 자식 순서대로 검색
空きノードが K 個未満しかない場合，存在する空きノードの分だけ新規オーナメントを配置する．
빈 노드가 K개 미만이면, 현재 비어있는 노드수를 나타내는 신규 오나멘트를 배치한다.???
各年の処理が終わるたびに，ツリー全体をレベル順に出⼒する．
각년도 처리 후 전체 트리가 레벨 순서대로 출력
problem.md 2025-12-11
2 / 7


⼊⼒
⼊⼒は次の形式で与えられる︓
D
add_count_year1
add_count_year2
add_count_year3
add_count_year4
add_count_year5
D はツリーの深さ（根の深さを 1 とする）．
1 ≤ D ≤ 8 を想定する（ノード数は最⼤で 2^8 - 1 < 256）．
add_count_yearX（X = 1..5）は，各年に追加したいオーナメントの数 K であり，整数 0 以上とする．

なお，ツリーの各ノードの初期 value は，プログラム中に定義された 16×16 の整数配列から，
深さ優先・左部分⽊ → 右部分⽊ の順で⾃動的に設定される．受験者はこの初期化⽅法を変更してはならない．

D는 트리의 깊이(루트 깊이를 1)
D <= 8 <=1이라 가정(노드 수는 최대 2^8 - 1 < 256)
add_count_yearX (X = 1..5)는 매년 추가하고자 하는 장식 K 개, 정수는 0 이상
트리 내 각 노드의 초기 값은 프로그램에서 정의된 16×16 정수 배열에서 도출됨에 주의
깊이 우선순위, 좌>우 부분 트리는 다음 순서로 자동 설정:
이 초기화 방식을 변경해서는 안 됩니다


出⼒
プログラムは，処理の進⾏に応じて次のようなメッセージとツリーの状態を出⼒する。
과정이 진행됨에 따라 프로그램은 다음 메시지와 트리 상태를 출력
1. 最初に 최초에
ツリーの深さを入⼒:
트리 깊이 입력됨
の 1 ⾏を出⼒し，D を読み込む．
한 줄을 출력 D
2. 続いて，初期状態のツリーを
初期状態:
（レベル1）
（レベル2）
...
の形式で出⼒する。各レベルごとに 1 ⾏，ノードの value を半⾓スペース区切りで出⼒する。
レベル出⼒の最後には空⾏を 1 ⾏⼊れる。
3. 各年 year = 1..5 について，次の順で出⼒する︓
1. 年度⾒出し
problem.md 2025-12-11
3 / 7
********** year年⽬ **********
2. 追加個数の⼊⼒プロンプト
追加したいオーナメントの数:
3. メンテナンス後の⾒出しとツリー
メンテナンス後:
（レベル1）
（レベル2）
...
ここでも各レベル1⾏＋最後に空⾏を出⼒する。
出⼒例はサンプルを参照せよ。
注意︓出⼒は cout ⽂の内容と順番により判定されるため，
初期コードに記載された cout ⽂は変更してはならない。
サンプル
サンプル1
⼊⼒
2
1
1
1
1
1
出⼒
ツリーの深さを入⼒:
初期状態:
4
9 5
********** 1年⽬ **********
追加したいオーナメントの数:
problem.md 2025-12-11
4 / 7
メンテナンス後:
4
0 5
********** 2年⽬ **********
追加したいオーナメントの数:
メンテナンス後:
5
1 0
********** 3年⽬ **********
追加したいオーナメントの数:
メンテナンス後:
0
2 1
********** 4年⽬ **********
追加したいオーナメントの数:
メンテナンス後:
1
3 2
********** 5年⽬ **********
追加したいオーナメントの数:
メンテナンス後:
2
4 3
サンプル2
⼊⼒
4
2
1
2
1
1
出⼒
ツリーの深さを入⼒:
初期状態:
4 
problem.md 2025-12-11
5 / 7
9 0
5 3 9 5
2 5 2 4 0 5 5 0
********** 1年⽬ **********
追加したいオーナメントの数:
メンテナンス後:
4
0 0
5 3 0 5
2 5 2 4 0 5 5 0
********** 2年⽬ **********
追加したいオーナメントの数:
メンテナンス後:
5
1 1
9 4 1 0
3 9 3 5 1 9 9 1
********** 3年⽬ **********
追加したいオーナメントの数:
メンテナンス後:
0
2 2
0 5 2 1
4 9 4 9 2 9 9 2
********** 4年⽬ **********
追加したいオーナメントの数:
メンテナンス後:
1
3 3
1 0 3 2
5 9 5 9 3 9 9 3
********** 5年⽬ **********
追加したいオーナメントの数:
メンテナンス後:
2
4 4
2 1 4 3
9 9 9 9 4 9 0 4
サンプル3
problem.md 2025-12-11
6 / 7
⼊⼒
3
3
2
4
1
2
出⼒
ツリーの深さを入⼒:
初期状態:
4
9 5
5 2 3 2
********** 1年⽬ **********
追加したいオーナメントの数:
メンテナンス後:
4
0 5
5 2 3 2
********** 2年⽬ **********
追加したいオーナメントの数:
メンテナンス後:
5
1 0
0 3 4 3
********** 3年⽬ **********
追加したいオーナメントの数:
メンテナンス後:
0
2 1
1 4 5 4
********** 4年⽬ **********
追加したいオーナメントの数:
メンテナンス後:
1
3 2
2 5 0 5
********** 5年⽬ **********
problem.md 2025-12-11
7 / 7
追加したいオーナメントの数:
メンテナンス後:
2
4 3
3 0 1 0 
 */
// 与えられた乱数256値（16×16）
int rand_values[RAND_SIZE][RAND_SIZE] = {
    {4,9,5,2,5,3,2,4,0,9,0,5,5,5,0,1},
    {1,0,3,1,3,1,9,0,3,5,0,2,1,3,0,4},
    {3,5,1,5,2,2,5,0,5,1,4,1,2,2,3,4},
    {1,2,9,2,3,0,2,2,0,3,5,5,5,3,2,3},
    {0,2,0,5,3,5,0,3,1,1,1,2,0,3,3,1},
    {0,4,4,2,4,0,4,2,2,1,2,0,5,1,1,2},
    {3,2,1,1,0,5,5,0,0,1,1,5,1,2,4,1},
    {0,0,2,5,0,4,3,4,4,3,1,2,1,0,1,5},
    {5,1,2,9,4,2,4,0,3,9,1,9,5,5,3,2},
    {2,4,3,4,2,0,3,1,5,0,0,3,2,4,4,0},
    {5,0,9,3,5,2,1,3,1,2,5,5,1,2,5,4},
    {4,0,2,2,1,0,2,2,4,5,0,1,4,4,1,5},
    {3,2,5,1,0,2,5,2,3,2,2,3,3,2,1,4},
    {1,0,3,4,4,0,4,4,5,3,0,0,0,2,3,2},
    {0,0,4,4,1,2,1,4,4,2,3,4,5,0,0,5},
    {4,0,5,2,2,3,2,0,5,0,4,4,1,4,2,2}
};

class Node {
public:
    int value;
    Node* left;
    Node* right;
};

// 完全二分木構築
Node* BuildTree(int depth, int& idx) {
    if (depth == 0) {
        return NULL;
    }

    Node* node = new Node();
    node->value = rand_values[idx / 16][idx % 16];
    node->left = NULL;
    node->right = NULL;
    idx++;

    node->left = BuildTree(depth - 1, idx);
    node->right = BuildTree(depth - 1, idx);

    return node;
}

// 木の深さ取得
int GetDepth(Node* node) {
    if (node == NULL) {
        return 0;
    }
    int left_depth = GetDepth(node->left);
    int right_depth = GetDepth(node->right);

    if (left_depth > right_depth) {
        return left_depth + 1;
    }
    else {
        return right_depth + 1;
    }
}

// レベル順出力
void PrintLevel(Node* node, int level) {
    if (node == NULL) {
        return;
    }

    if (level == 0) {
        cout << node->value << " ";
    }
    else {
        PrintLevel(node->left, level - 1);
        PrintLevel(node->right, level - 1);
    }
}

void PrintTree(Node* root) {
    int depth = GetDepth(root);

    for (int i = 0; i < depth; i++) {
        PrintLevel(root, i);
        cout << endl;
    }
    cout << endl;
}

// レベル順（上→下）かつ 右→左 の順で 9 を探索し 0 を置く
bool PlaceOrnament(Node* root) {

    /*回答記入箇所①*/
    // ヒント：
    // - 配列を使った簡易キューで BFS を実装する
    // - 右の子 → 左の子 の順でキューに追加すると
    //   「上から順・右優先」の探索順になる

    if (root == NULL) {
        return false;
    }

    Node* queue[512];
    int head = 0;
    int tail = 0;
    queue[tail++] = root;

    while (head < tail) {
        Node* current = queue[head++];
        if (current->value == 9) {
            current->value = 0;
            return true;
        }
        if (current->right != NULL) {
            queue[tail++] = current->right;
        }
        if (current->left != NULL) {
            queue[tail++] = current->left;
        }
    }

    return false;  // 空きが見つからなかった場合
}

// メンテナンス撤去
void MaintenanceRemove(Node* node) {

    /*回答記入箇所②*/
    // ヒント：
    // - 再帰で木全体を走査する
    // - value > 5 のノードを 9 に更新する

    if (node == NULL) {
        return;
    }

    if (node->value > 5) {
        node->value = 9;
    }

    MaintenanceRemove(node->left);
    MaintenanceRemove(node->right);
}

// 年数加算
void AddYear(Node* node) {

    /*回答記入箇所③*/
    // ヒント：
    // - 再帰で木全体を走査する
    // - value が 0〜5 のときだけ value を +1 する
    // - value が 9（撤去済み）はそのまま

    if (node == NULL) {
        return;
    }

    if (node->value >= 0 && node->value <= 5) {
        node->value += 1;
    }

    AddYear(node->left);
    AddYear(node->right);

}

int main() {

    int level;
    cout << "ツリーの深さを入力:" << endl;
    cin >> level;

    int idx = 0;
    Node* root = BuildTree(level, idx);

    cout << "初期状態:" << endl;
    PrintTree(root);

    // 5年間の処理
    for (int year = 1; year <= 5; year++) {
        cout << "********** " << year << "年目 **********" << endl;
        // 1. 経過年数 +1（9は除外）
        if (year != 1) {
            AddYear(root);
        }

        int add_count;
        cout << "追加したいオーナメントの数:" << endl;
        cin >> add_count;

        // 2. メンテナンス撤去
        MaintenanceRemove(root);

        // 3. 新規追加
        for (int i = 0; i < add_count; i++) {
            PlaceOrnament(root);
        }

        cout << endl;
        cout << "メンテナンス後:" << endl;
        PrintTree(root);
    }

    return 0;
}
